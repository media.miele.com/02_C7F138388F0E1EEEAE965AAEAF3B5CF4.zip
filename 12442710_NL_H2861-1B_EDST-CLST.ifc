Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-18T08:23:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 18 08:23:43 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\99a0ea2c-2062-4ada-8916-edec7e9b3746\8bd6ec1d-b94d-49e1-afc6-b6aa3ef362ea\ifc * Database version: 5507 * Database creation date: Thu Jan 18 08:23:41 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 18 08:23:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 18 08:23:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12442710_NL_H2861-1B_EDST-CLST:22286194_NL_12442710_H2861-1B_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22286194_NL_12442710_H2861-1B_EDST-CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22286194_NL_12442710_H2861-1B_EDST-CLST
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Alusilver, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_353920
Description: Flow; FlowDirection: SOURCEANDSINK
